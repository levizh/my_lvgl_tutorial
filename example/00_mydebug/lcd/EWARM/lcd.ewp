# IAR project lcd.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ev_hc32f4a0_lqfp176; ..\..\..\..\bsp\components\nt35510; ..\..\..\..\bsp\components\tca9539; ..\..\..\..\bsp\components\gt9147; ..\source\lvgl\src\lv_core; ..\source\lvgl\src\lv_draw; ..\source\lvgl\src\lv_font; ..\source\lvgl\src\lv_hal; ..\source\lvgl\src\lv_misc; ..\source\lvgl\src\lv_objx; ..\source\lvgl\src\lv_themes; ..\source\lvgl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lcd.srec
  ILINK.IlinkOutputFile: lcd.out
  ILINK.IlinkIcfFile: hc32f4a0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ev_hc32f4a0_lqfp176; ..\..\..\..\bsp\components\nt35510; ..\..\..\..\bsp\components\tca9539; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme.txt
  group bsp
    ../../../../bsp/: i2c_drv.c
  group bsp/ev_hc32f4a0_lqfp176
    ../../../../bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_gt9147.c ev_hc32f4a0_lqfp176_nt35510.c ev_hc32f4a0_lqfp176_tca9539.c
  group bsp/gt9147
    ../../../../bsp/components/gt9147/: gt9147.c
  group bsp/nt35510
    ../../../../bsp/components/nt35510/: nt35510.c
  group bsp/tca9539
    ../../../../bsp/components/tca9539/: tca9539.c
  group common
    ./: startup_hc32f4a0.s
    ../../../../mcu/common/: system_hc32f4a0.c
  group driver
    ../../../../driver/src/: hc32f4a0_clk.c hc32f4a0_dma.c hc32f4a0_efm.c hc32f4a0_gpio.c hc32f4a0_i2c.c hc32f4a0_icg.c hc32f4a0_interrupts.c hc32f4a0_keyscan.c hc32f4a0_pwc.c hc32f4a0_smc.c hc32f4a0_sram.c hc32f4a0_utility.c
  group lvgl/lv_examples/apps/benchmark
    ../source/lv_examples/lv_apps/benchmark/: benchmark.c benchmark_bg.c
  group lvgl/lv_examples/apps/demo
    ../source/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
  group lvgl/lv_examples/apps/sysmon
    ../source/lv_examples/lv_apps/sysmon/: sysmon.c
  group lvgl/lv_examples/apps/terminal
    ../source/lv_examples/lv_apps/terminal/: terminal.c
  group lvgl/lv_examples/apps/tpcal
    ../source/lv_examples/lv_apps/tpcal/: tpcal.c
  group lvgl/lv_examples/tests/group
    ../source/lv_examples/lv_tests/lv_test_group/: lv_test_group.c
  group lvgl/lv_examples/tests/misc
    ../source/lv_examples/lv_tests/lv_test_misc/: lv_test_task.c
  group lvgl/lv_examples/tests/obj
    ../source/lv_examples/lv_tests/lv_test_obj/: lv_test_obj.c
  group lvgl/lv_examples/tests/objx/arc
    ../source/lv_examples/lv_tests/lv_test_objx/lv_test_arc/: lv_test_arc.c
  group lvgl/lv_examples/tests/objx/bar
    ../source/lv_examples/lv_tests/lv_test_objx/lv_test_bar/: lv_test_bar.c
  group lvgl/lv_examples/tests/objx/btn
    ../source/lv_examples/lv_tests/lv_test_objx/lv_test_btn/: lv_test_btn.c
  group lvgl/lv_examples/tests/objx/imgbtn
    ../source/lv_examples/lv_tests/lv_test_objx/lv_test_imgbtn/: imgbtn_img_1.c imgbtn_img_2.c imgbtn_img_3.c imgbtn_img_4.c lv_test_imgbtn.c
  group lvgl/lv_examples/tests/stress
    ../source/lv_examples/lv_tests/lv_test_stress/: lv_test_stress.c
  group lvgl/lv_examples/tests/theme
    ../source/lv_examples/lv_tests/lv_test_theme/: lv_test_theme_1.c lv_test_theme_2.c
  group lvgl/lv_examples/turorial/01_hello_world
    ../source/lv_examples/lv_tutorial/1_hello_world/: lv_tutorial_hello_world.c
  group lvgl/lv_examples/turorial/02_objx
    ../source/lv_examples/lv_tutorial/2_objects/: lv_tutorial_objects.c
  group lvgl/lv_examples/turorial/03_style
    ../source/lv_examples/lv_tutorial/3_styles/: lv_tutorial_styles.c
  group lvgl/lv_examples/turorial/04_themes
    ../source/lv_examples/lv_tutorial/4_themes/: lv_tutorial_themes.c
  group lvgl/lv_examples/turorial/05_antialiasing
    ../source/lv_examples/lv_tutorial/5_antialiasing/: apple_icon_alpha.c apple_icon_chroma.c lv_tutorial_antialiasing.c
  group lvgl/lv_examples/turorial/06_images
    ../source/lv_examples/lv_tutorial/6_images/: flower_icon_alpha.c lv_tutorial_images.c red_flower.c red_rose_16.c
  group lvgl/lv_examples/turorial/07_fonts
    ../source/lv_examples/lv_tutorial/7_fonts/: arial_20.c lv_tutorial_fonts.c
  group lvgl/lv_examples/turorial/08_animations
    ../source/lv_examples/lv_tutorial/8_animations/: lv_tutorial_animations.c
  group lvgl/lv_examples/turorial/09_responsive
    ../source/lv_examples/lv_tutorial/9_responsive/: lv_tutorial_responsive.c
  group lvgl/lv_examples/turorial/10_keyboard
    ../source/lv_examples/lv_tutorial/10_keyboard/: lv_tutorial_keyboard.c
  group lvgl/porting
    ../source/lvgl/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group lvgl/src/lv_core
    ../source/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lvgl/src/lv_draw
    ../source/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/lv_font
    ../source/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
  group lvgl/src/lv_hal
    ../source/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/lv_misc
    ../source/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group lvgl/src/lv_objx
    ../source/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lvgl/src/lv_themes
    ../source/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group source
    ../source/: main.c
