# IAR project exmc_nfc_nandflash_mt29f2g08ab.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ev_hc32f4a0_lqfp176; ..\..\..\..\bsp\components\mt29f2g08ab; ..\..\..\..\bsp\components\tca9539
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exmc_nfc_nandflash_mt29f2g08ab.srec
  ILINK.IlinkOutputFile: exmc_nfc_nandflash_mt29f2g08ab.out
  ILINK.IlinkIcfFile: hc32f4a0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F4A0; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\bsp\ev_hc32f4a0_lqfp176; ..\..\..\..\bsp\components\mt29f2g08ab; ..\..\..\..\bsp\components\tca9539; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32f4a0.c
    ./: startup_hc32f4a0.s
  group driver
    ../../../../driver/src/: hc32f4a0_gpio.c hc32f4a0_nfc.c hc32f4a0_sram.c hc32f4a0_i2c.c hc32f4a0_keyscan.c hc32f4a0_clk.c hc32f4a0_efm.c hc32f4a0_interrupts.c hc32f4a0_utility.c hc32f4a0_icg.c hc32f4a0_pwc.c
  group bsp/ev_hc32f4a0_lqfp176
    ../../../../bsp/ev_hc32f4a0_lqfp176/: ev_hc32f4a0_lqfp176.c ev_hc32f4a0_lqfp176_mt29f2g08ab.c ev_hc32f4a0_lqfp176_tca9539.c
  group bsp/mt29f2g08ab
    ../../../../bsp/components/mt29f2g08ab/: mt29f2g08ab.c
  group bsp/tca9539
    ../../../../bsp/components/tca9539/: tca9539.c
  group source
    ../source/: main.c
    ../../../../example/exmc/exmc_nfc_nandflash_mt29f2g08ab/source/: 1bit_per_512byte_ecc.c a_to_i.c decode_4bit_ecc_err_loc.c i_to_a.c
